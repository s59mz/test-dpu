options:
  parameters:
    generate_options: qt_gui
    id: RF_Classification
    output_language: python
    title: RF Classification
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,1
    label: Freq [MHz]
    type: real
    value: '144.8'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: Gain
    orient: Qt.Vertical
    start: '0.1'
    step: '0.1'
    stop: '3'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '288000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Squelch
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '-20'
    value: '-52'
    widget: dial
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '2700'
    gain: '1.0'
    samp_rate: samp_rate/dec
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '72000'
    max_dev: 5e3
    quad_rate: '72000'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:0,0
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_decimator_0
  id: blocks_stream_to_vector_decimator
  parameters:
    sample_rate: samp_rate/dec
    type: complex
    vec_rate: '10'
    vlen: '1024'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: fpga_ai_rf_classf_0
  id: fpga_ai_rf_classf
  parameters:
    model_filename: /media/sd-mmcblk1p1/test-dpu/models/rfClassification.xmodel
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '26'
    grid: 'True'
    gui_hint: 3,3,3,3
    label1: Inference
    marker1: '0'
    name: '"Modulation Inference / Class Index"'
    size: '32'
    style1: '3'
    type: float
    xmax: '23'
    xmin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,3,1,3
    label1: I-Signal
    label2: Q-Signal
    name: '"I/Q Signal"'
    size: '1024'
    srate: samp_rate/dec
    type: complex
    update_time: '1'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/dec
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    name: '"RF Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '2'
    taps: taps
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: freq*1e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq-data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq-data
  states: {}

connections:
- [analog_nbfm_rx_0, '0', hilbert_fc_0, '0']
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_decimator_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_short_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_stream_to_vector_decimator_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_decimator_0, '0', fpga_ai_rf_classf_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [fpga_ai_rf_classf_0, '0', blocks_short_to_float_0, '0']
- [hilbert_fc_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
